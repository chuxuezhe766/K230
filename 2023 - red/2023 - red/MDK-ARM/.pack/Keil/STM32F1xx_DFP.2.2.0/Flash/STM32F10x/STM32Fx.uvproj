# Keil uVision project STM32Fx.uvproj, settings and files
target STM32F10x_16 (ARM-ADS)
  device: STM32F103V8T6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10x_16
  AfterMake: cmd.exe /C copy STM32F10x_16.axf ..\STM32F10x_16.FLM
  c flags: Optim=1
  c define: FLASH_MEM, STM32F10x_16
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32F10x_128 (ARM-ADS)
  device: STM32F103V8T6 STMicroelectronics
  cpu: as above
  output: STM32F10x_128
  AfterMake: cmd.exe /C copy STM32F10x_128.axf ..\STM32F10x_128.FLM
  c flags: Optim=1
  c define: FLASH_MEM, STM32F10x_128
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F10x_512 (ARM-ADS)
  device: STM32F103V8T6 STMicroelectronics
  cpu: as above
  output: STM32F10x_512
  AfterMake: cmd.exe /C copy STM32F10x_512.axf ..\STM32F10x_512.FLM
  c flags: Optim=1
  c define: FLASH_MEM, STM32F10x_512
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F10x_1024 (ARM-ADS)
  device: STM32F103V8T6 STMicroelectronics
  cpu: as above
  output: STM32F10x_1024
  AfterMake: cmd.exe /C copy STM32F10x_1024.axf ..\STM32F10x_1024.FLM
  c flags: Optim=1
  c define: FLASH_MEM, STM32F10x_1024
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F10x_CL (ARM-ADS)
  device: STM32F103V8T6 STMicroelectronics
  cpu: as above
  output: STM32F10x_CL
  AfterMake: cmd.exe /C copy STM32F10x_CL.axf ..\STM32F10x_CL.FLM
  c flags: Optim=1
  c define: FLASH_MEM, STM32F10x_CL
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F10x_OPT (ARM-ADS)
  device: STM32F103V8T6 STMicroelectronics
  cpu: as above
  output: STM32F10x_OPT
  AfterMake: cmd.exe /C copy STM32F10x_OPT.axf ..\STM32F10x_OPT.FLM
  c flags: Optim=1
  c define: FLASH_OPT
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
