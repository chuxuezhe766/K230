# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32E (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0-dev9
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E LCD_LG (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0-dev9
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Joystick 2.0.0, Board Support:emWin LCD 2.0.0, Device:GPIO 1.3, Device:Startup 1.0.0, Graphics:CORE 5.36.6, Graphics:Demo:ColorBar 5.36.6, Graphics:Demo:Framework 5.36.6, Graphics:Demo:Graph 5.36.6, Graphics:Demo:ListView 5.36.6, Graphics:Demo:Speed 5.36.6, Graphics:Demo:TransparentDialog 5.36.6, Graphics:Demo:Treeview 5.36.6, Graphics:Display:MCBQVGA_LD 5.36.6, Graphics:Display:MCBQVGA_LG 5.36.6, Graphics:Input Device:Joystick 5.36.6
