# Keil uVision project FTP_Server.uvprojx, settings and files
target STM32F107 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0-dev9
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FTP_Server
  c flags: Optim=4 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: FTP_Server.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, File System:CORE 6.5.2, File System:Drive:Memory Card 6.5.2, Network:CORE 6.5.2, Network:Interface:ETH 6.5.2, Network:Service:FTP Server 6.5.2, Network:Socket:TCP 6.5.2, Network:Socket:UDP 6.5.2, CMSIS Driver:Ethernet MAC 2.0, CMSIS Driver:Ethernet PHY:DP83848C 6.00, CMSIS Driver:SPI 2.0, Compiler:I/O:File 1.0.0, Compiler:I/O:TTY 1.0.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0
