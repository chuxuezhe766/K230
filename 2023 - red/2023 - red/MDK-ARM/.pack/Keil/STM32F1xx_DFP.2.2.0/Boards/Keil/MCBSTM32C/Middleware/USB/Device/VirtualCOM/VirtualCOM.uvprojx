# Keil uVision project VirtualCOM.uvprojx, settings and files
target STM32F107 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0-dev9
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: VirtualCOM
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: VirtualCOM.c USBD_User_CDC_ACM_UART_0.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, USB:CORE 6.6.17, USB:Device 6.6.17, USB:Device:CDC 6.6.17, CMSIS Driver:SPI 2.2, CMSIS Driver:USART 2.1, CMSIS Driver:USB Device 2.1, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
