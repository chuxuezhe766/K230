# Keil uVision project Example.uvprojx, settings and files
target MCBSTM32C (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0-dev9
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Example
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C LCD_LG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0-dev9
  cpu: as above
  output: Example
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:emWin LCD 2.0.0, CMSIS Driver:SPI 2.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0, Graphics:CORE 5.30.0, Graphics:Display:MCBQVGA_LD 5.30.0, Graphics:Display:MCBQVGA_LG 5.30.0
