# Keil uVision project MassStorage.uvprojx, settings and files
target STM32F103 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0-dev9
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MassStorage
  c flags: Optim=4 OneElfS=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: MassStorage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:Graphic LCD 2.0.0, File System:CORE 6.5.0, File System:Drive:Memory Card 6.5.0, USB:CORE 6.5.0, USB:Device 6.5.0, USB:Device:MSC 6.5.0, CMSIS Driver:MCI 2.0, CMSIS Driver:USB Device 2.0, Compiler:I/O:File 1.0.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0
