# Keil uVision project HTTP_Server.uvprojx, settings and files
target STM32F107 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0-dev12
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:Web Server Compact 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, CMSIS Driver:Ethernet MAC 2.1, CMSIS Driver:Ethernet PHY:DP83848C 6.1, CMSIS Driver:SPI 2.2, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
