# Keil uVision project HTTP_Server.uvprojx, settings and files
target STM32F107 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0-dev9
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: ad.cgi ad.cgx buttons.cgi buttons.cgx home.png index.htm keil.gif language.cgi lcd.cgi leds.cgi llblue.jpg logo.gif network.cgi pabb.gif pg_footer.inc pg_header.inc system.cgi tcp.cgi xml_http.js
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Network:CORE 6.5.2, Network:Interface:ETH 6.5.2, Network:Service:Web Server Compact 6.5.2, Network:Socket:TCP 6.5.2, Network:Socket:UDP 6.5.2, CMSIS Driver:Ethernet MAC 2.0, CMSIS Driver:Ethernet PHY:DP83848C 6.00, CMSIS Driver:SPI 2.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0
