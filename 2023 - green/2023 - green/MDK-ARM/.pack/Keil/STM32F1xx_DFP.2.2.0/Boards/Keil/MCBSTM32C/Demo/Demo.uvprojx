# Keil uVision project Demo.uvprojx, settings and files
target STM32F107 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0-dev9
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Demo
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: Demo.c Arrows_16bpp_red.c Bulb_16bpp.c Button_16bpp.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:A/D Converter 2.0.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:Joystick 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:I2C 2.0, CMSIS Driver:SPI 2.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0
